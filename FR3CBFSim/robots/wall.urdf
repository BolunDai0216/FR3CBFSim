Commit message: updated wall

File: FR3CBFSim/robots/wall.urdf (robot description, URDF)
Before this commit: robot wall, 2 links, 1 joints
Links:
- link wall_link: geometry collision box size=2 0.2 1.0; visual box size=2 0.2 1.0
